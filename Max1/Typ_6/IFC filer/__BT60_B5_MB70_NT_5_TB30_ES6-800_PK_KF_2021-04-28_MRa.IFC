Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: __BT60_B5_MB70_NT_5_TB30_ES6-800_PK_KF_2021-04-28_MRa.IFC
Time: 2021-04-28T06:29:46
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
